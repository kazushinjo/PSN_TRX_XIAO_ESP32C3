# Repository kazushinjo/PSN_TRX_XIAO_ESP32C3

File README.md:

# PSN_TRX_XIAO_ESP32C3

Arduino Nano R4 + Seeed Studio XIAO ESP32C3 + Si5351 を使用した PSN 方式 SSB トランシーバー（KiCad 10.0）。

## 概要

50MHz 帯 PSN（位相シフト網）方式 SSB トランシーバー。VXO（水晶発振器）を
Si5351A クロックジェネレーターによる VFO に置き換え、Arduino Nano R4 でデジタル制御する。

Si5351 の CLK0（0°）/ CLK1（90°）二相出力を直接バランスドモジュレーターへ供給することで、
従来の RF PSN（LC 位相シフト回路）も不要となる。

## 主な仕様

| 項目 | 内容 |
|---|---|
| 周波数範囲 | 50.000 〜 51.000 MHz（6m バンド） |
| CLK0 出力 | 0° キャリア → C21（バランスドモジュレーター） |
| CLK1 出力 | 90° キャリア → C22（バランスドモジュレーター） |
| チューニングステップ | 10Hz / 100Hz / 1kHz / 10kHz / 100kHz |
| 表示 | OLED SSD1306 128×64 |
| 周波数記憶 | NVS（電源 OFF 後も保持） |

## ハードウェア構成

```
Arduino Nano R4
├── Seeed Studio XIAO ESP32C3 ─ サブコントローラ
├── Si5351A モジュール (AE-Si5351A) ─ I2C クロックジェネレーター
│   ├── CLK0（0°）  → バランスドモジュレーター C21
│   └── CLK1（90°） → バランスドモジュレーター C22
└── OLED / ロータリーエンコーダ 等

1W PA: RD06HVF1 (N-ch RF MOSFET) @ 12V, Class AB
```

## 1W パワーアンプ（Q8）

前段（2SC1815 等）の出力（約 20〜30mW）を増幅する終段アンプ。

| 項目 | 内容 |
|---|---|
| トランジスタ | **RD06HVF1**（三菱電機 N-ch RF MOSFET, 175MHz, 6W, TO-220F） |
| 電源電圧 | 12V |
| 動作クラス | Class AB |
| 静止電流 Idq | 200〜400mA（VR3 で調整） |
| 出力 | 約 1W @50MHz |
| 出力 LPF | 56pF → 270nH → 56pF（カットオフ約 60MHz） |

### バイアス回路

```
VCC(12V) → R22(470Ω) ─┬─ VR3(500Ω) → GND
                       │    ↓（ワイパー）
                       └── R21(10Ω) → Q8ゲート
```

- VR3 を中間位置でゲート電圧 ≈ **3.1V** → RD06HVF1 の Class AB 動作に最適
- VR3 を徐々に回してドレイン電流 (Idq) 200〜400mA に合わせる
- D3, D4（旧バイアスダイオード）は **0R ショート**（MOSFET では不要）
- R20（旧エミッタ抵抗 10Ω）は **0R ショート**（ソース直結 GND）

詳細は `docs/PSN_TRX_VFO改造仕様書.docx` を参照。

## KiCad ライブラリ状態

| ファイル | 状態 |
|---|---|
| `kicad/PSN_TRX.pretty/` | 全12フットプリント KiCad 10 形式 ✅ |
| `kicad/PSN_TRX.kicad_sym` | カスタムシンボル（RD06HVF1 含む）✅ |
| `kicad/fp-lib-table` | PSN_TRX ライブラリ登録済み ✅ |
| DRC ライブラリエラー | **0件** ✅ |

## ファイル構成

```
kicad/
  PSN_TRX.kicad_sch       - 回路図
  PSN_TRX.kicad_pcb       - PCB レイアウト（配線作業中）
  PSN_TRX.kicad_sym       - カスタムシンボルライブラリ
  PSN_TRX.pretty/         - カスタムフットプリントライブラリ（12点）
  BOM.md                  - 部品表（Markdown）
  bom.csv                 - 部品表（Shift-JIS CSV・入手先情報付き）
docs/
  PSN_TRX_VFO改造仕様書.docx  - 改造仕様書（部品リスト・回路図含む）
```

## 変更履歴

| 日付 | 変更内容 |
|---|---|
| 2026-06-20 | KiCad 回路図から bom.csv を新規生成（Shift-JIS）、入手先情報（秋月電子・サトー電気等）追加 |
| 2026-06-17 | Q3: 3SK59(TO-72 THT) → BF998(SOT-143 SMD)、カスタムシンボル・FP追加 |
| 2026-06-17 | Q8: 2SC1971 → RD06HVF1 (RF MOSFET) 換装、バイアス回路変更 |
| 2026-06-17 | KiCad 10 フットプリントライブラリ全面更新（12ファイル） |
| 2026-06-17 | U2: DIP-12 → DIP-8 フットプリント修正（AE-Si5351A 実寸合わせ） |

## ライセンス

MIT License

## 作者

JA3 (kazushinjo)

## KiCad design kicad/PSN_TRX.kicad_pcb

Parts:
C1, C2, C5, C8, C10: 1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C3, C4, C9: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C6, C12, C22, C30, C34, C37: 15p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C7, C13, C14, C15, C23, C24, C25, C32, C33, C35, C36, C39, C40, C45, C48, C49: 0.01u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C11, C16: 100u; CP_Radial_D6.3mm_P2.50mm
C17, C18, C19, C20: 10u; CP_Radial_D5.0mm_P2.00mm
C21, C38, C44: 0.001u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C27: 0.1uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C28, C29: 100pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C31: 22pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C41, C42, C46, C47: 47PF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C43: 5p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C60: 1u; CP_Radial_D5.0mm_P2.00mm
D1, D2, D5, D6, D7, D8: 1N60; D_DO-35_SOD27_P2.54mm_Vertical_CathodeUp
IC1: LP2950L-5.0V; TO-92_Inline
IC2: NJM2904; DIP-8_W7.62mm
J1: RF_IN; PinHeader_1x02_P2.54mm_Vertical
J2: SP-OUT; PinHeader_1x02_P2.54mm_Vertical
J3: PWR_IN; PinHeader_1x02_P2.54mm_Vertical
J4, J5: Volume; PinHeader_1x03_P2.54mm_Vertical
J6: Encoder; PinHeader_1x04_P2.54mm_Vertical
J7: I2C_OUT-LCD; PinHeader_1x03_P2.54mm_Vertical
J8: MIC-IN; PinHeader_1x04_P2.54mm_Vertical
J9: TX-ON-LED; PinHeader_1x02_P2.54mm_Vertical
J10: TJC4832T135; PinHeader_1x04_P2.54mm_Vertical
K1: G5V-2; Relay_DPDT_Omron_G5V-2
L1, L2, L3, L7, L8, L9: 7T50; L_FCZ07S_CT
L4, L5: T-50-10 18T/0.4mm; L_T50_2pin_Vertical
L6: 47nH; L_Axial_L9.5mm_D4.0mm_P12.70mm_Horizontal_Fastron_SMCC
L10, L11: 100nH; L_AL0510-153K_Vertical
L12, L13: 1mH; L_AL0510-153K_Vertical
L14: 15mH; L_AL0510-153K_Vertical
LED1: LED; PinHeader_1x02_P2.54mm_Vertical
LED2: LED黄; PinHeader_1x02_P2.54mm_Vertical
Q1: 2SC2120; TO-92_Inline
Q2, Q5, Q9, Q11, Q12, Q13, Q14: 2SC1815; TO-92_Inline
Q3: BF998; BF998_SOT143
Q4: 2SC1923; TO-92_Inline
Q6: 2SA950; TO-92_Inline
Q7, Q10: 2SK439; TO-92_Inline
Q8: RD06HVF1; TO-220-3_Vertical
R1, R2, R17, R35: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3: 1.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R4, R7, R11, R12, R16, R25, R32, R36, R41: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5, R37, R39: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R6, R8, R31, R34: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R9, R33, R40: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R10: 4.7; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R13: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R14, R28: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R15, R19: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R18, R23, R26: 51; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R21: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R22: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R24, R30, R38: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R27, R29: 47; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
RFC1: 10uH; L_Axial_L9.5mm_D4.0mm_P12.70mm_Horizontal_Fastron_SMCC
SW1, SW2: SW; SW_DIP_SPSTx01_Slide_6.7x4.1mm_W7.62mm_P2.54mm_LowProfile
Studio XIAO ESP32C3: Seeeduino_XIAO_Socket
T1: ST-71; Transformer_ST71_CB19
TC1: 30p; C_Trimmer_TMCV01
U1: LP2950-3.3_TO92; TO-92_Inline
U2: Si5351_DIP8; DIP-8_W7.62mm
VR1: 5k; Potentiometer_TOCOS_GF063P_Vertical; not fitted
VR2: 10k; Potentiometer_TOCOS_GF063P_Vertical; not fitted
VR3: 500; Potentiometer_Bourns_3266W_Vertical
VR4, VR6: 1k; Potentiometer_TOCOS_GF063P_Vertical
VR5, VR7: 500; Potentiometer_TOCOS_GF063P_Vertical
VR8: 10k; Potentiometer_TOCOS_GF063P_Vertical

Connections:
+5V: C19.1, IC1.1 (VO), IC2.8 (V+), J10.4, Studio XIAO ESP32C3.8 (VIN), U1.3 (VI)
+9V: C6.2, C14.1, C17.1, C18.1, IC1.3 (VI), K1.11, L1.3 (SB), R4.2, R9.2, R11.2, R12.2, R14.2, R15.2
/PHONE: C11.2, J2.1
GND: C3.2, C4.2, C9.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C23.2, C25.2, C27.2, C31.2, C32.2, C35.2, C36.2, C40.2, C41.1, C42.1, C46.1, C47.1, C48.2, C49.2, C55.2, C56.2, C57.2, D8.2 (A), IC1.2 (GND), IC2.4 (V-), IC2.5 (+), J1.2, J2.2, J3.2, J4.3, J5.3, J6.4, J7.3 (GND), J8.3, J10.1, L1.5 (AB), L2.3 (SB), L2.5 (AB), L3.5 (AB), L7.5 (AB), L8.5 (AB), L9.5 (AB), LED1.1 (K), Q1.3 (E), Q5.3 (E), Q8.3 (S), Q11.3 (E), R7.2, R10.2, R13.2, R17.2, R18.2, R23.2, R24.2, R26.2, R27.2, R28.2, R29.2, R37.2, R39.2, R41.2, SW1.1 (A), Studio XIAO ESP32C3.9 (GND), T1.2 (AB), T1.4 (SC), TC1.2, U1.2 (GND), U2.4 (GND), VR3.3
unnamed: C1.2, R5.1
unnamed: C2.2, C3.1, R3.1
unnamed: C24.2, C38.1, R27.1, VR5.1
unnamed: C28.2, L5.2
unnamed: C29.2, L6.1
unnamed: C38.2, L13.1, VR4.2
unnamed: C39.1, C42.2, L10.1
unnamed: C41.2, L10.2, VR5.2, VR5.3
unnamed: C43.1, K1.8, L4.1
unnamed: C44.1, R29.1, VR7.1
unnamed: C44.2, L12.1, VR6.2
unnamed: C45.1, C47.2, L11.1
unnamed: C46.2, L11.2, VR7.2, VR7.3
unnamed: C48.1, C50.1, L12.2
unnamed: C49.1, C59.1, L13.2
unnamed: C51.1, R34.2, VR8.2, VR8.3
unnamed: C52.2, C56.1, L14.1
unnamed: C53.1, C57.1, L14.2
unnamed: C54.2, IC2.1, R31.1
unnamed: C37.1, D1.2 (A), D5.2 (A), L9.1 (SA)
unnamed: D1.1 (K), VR4.1
unnamed: D2.2 (A), VR4.3
unnamed: C37.2, D2.1 (K), D7.1 (K), L9.3 (SB)
unnamed: D5.1 (K), VR6.1
unnamed: C43.2, D6.2 (A), D8.1 (K)
unnamed: D6.1 (K), Q11.1 (B), R28.1
unnamed: D7.2 (A), VR6.3
unnamed: IC2.3 (+), R31.2, R34.1
unnamed: C55.1, IC2.2 (-), VR8.1
unnamed: IC2.6 (-), IC2.7
unnamed: J1.1, K1.4
unnamed: J3.1, K1.13
unnamed: J4.1, R5.2
unnamed: C5.1, C10.2, J4.2
unnamed: J5.1, R15.1
unnamed: C13.1, J5.2, Q3.3 (G2)
unnamed: J6.1, Studio XIAO ESP32C3.1 (D0/A0)
unnamed: J6.2, Studio XIAO ESP32C3.2 (D1/A1)
unnamed: J6.3, Studio XIAO ESP32C3.3 (D2/A2)
unnamed: J7.2 (SCL), Studio XIAO ESP32C3.6 (D5/SCL), U2.2 (SCL)
unnamed: J7.1 (SDA), Studio XIAO ESP32C3.5 (D4/SDA), U2.3 (SDA)
unnamed: C58.2, J8.2, R36.2
unnamed: J9.1, Q11.2 (C)
unnamed: J9.2, R25.1
unnamed: J10.2, Studio XIAO ESP32C3.7 (D6/TX)
unnamed: J10.3, Studio XIAO ESP32C3.14 (D7/RX)
unnamed: K1.16, SW1.2 (B)
unnamed: C7.1, L1.4 (AA)
unnamed: C6.1, L1.1 (SA), Q3.4 (D)
unnamed: K1.6, L2.4 (AA)
unnamed: C12.1, L2.1 (SA), Q3.1 (G1)
unnamed: C21.2, L3.4 (AA)
unnamed: C22.1, L3.1 (SA), Q7.2 (D)
unnamed: C22.2, C23.1, L3.3 (SB)
unnamed: L4.2, L5.1, TC1.1
unnamed: C29.1, L7.4 (AA)
unnamed: L7.2 (CT), Q9.2 (C)
unnamed: C30.1, L7.1 (SA)
unnamed: C27.1, C30.2, C32.1, C34.2, C36.1, K1.9, L7.3 (SB), L8.3 (SB), R19.1, R22.1, R25.2, R30.1, R32.1, R36.1, R38.1, RFC1.1
unnamed: C33.2, L8.4 (AA)
unnamed: C34.1, L8.1 (SA), Q10.2 (D)
unnamed: L9.4 (AA), Q10.1 (G)
unnamed: LED1.2 (A), R16.2
unnamed: C5.2, Q1.1 (B), R6.1
unnamed: C11.1, Q1.2 (C), Q6.2 (C), R6.2, R8.1
unnamed: C4.1, Q2.1 (B), R1.1, R3.2
unnamed: C1.1, Q2.2 (C), R1.2, R4.1
unnamed: C9.1, Q2.3 (E), R7.1
unnamed: C15.1, Q3.2 (S), R13.1
unnamed: C7.2, Q4.1 (B), R9.1
unnamed: C8.1, Q4.2 (C), R11.1
unnamed: C21.1, Q4.3 (E), R10.1
unnamed: C8.2, Q5.1 (B), R2.1
unnamed: C2.1, Q5.2 (C), R2.2, R12.1
unnamed: C10.1, Q6.1 (B), R8.2
unnamed: C16.1, Q6.3 (E), R14.1
unnamed: C24.1, Q7.1 (G), R17.1
unnamed: C25.1, Q7.3 (S), R18.1
unnamed: C28.1, Q8.2 (D), RFC1.2
unnamed: C31.1, L6.2, Q8.1 (G), R21.1
unnamed: C33.1, Q9.1 (B), R19.2, R24.1
unnamed: C35.1, Q9.3 (E), R23.1
unnamed: C40.1, Q10.3 (S), R26.1
unnamed: C54.1, Q12.1 (B), R33.2
unnamed: C50.2, Q12.2 (C), R30.2, R33.1
unnamed: Q12.3 (E), R37.1
unnamed: C58.1, Q13.1 (B), R35.2
unnamed: C53.2, Q13.2 (C), R32.2, R35.1
unnamed: Q13.3 (E), R39.1
unnamed: C60.1, Q14.1 (B), R40.2
unnamed: C59.2, Q14.2 (C), R38.2, R40.1
unnamed: Q14.3 (E), R41.1
unnamed: R16.1, SW2.2 (B)
unnamed: R21.2, VR3.2
unnamed: R22.2, VR3.1
unnamed: C52.1, T1.1 (AA)
unnamed: C60.2, T1.3 (SA)
unnamed: C51.2, T1.5 (SB)
unnamed: C20.1, U1.1 (VO), U2.8 (VDD)
unnamed: C39.2, U2.5 (CLK0)
unnamed: C45.2, U2.6 (CLK1)

Notes on the sheet:
合成・平衡変調
DDS
低周波増幅
AF PSN・信号分割
RF PSN
高周波増幅
終段増幅
励振増幅
マイクアンプ

Board: 4 copper layers, 157 parts (0 on the bottom side), 102 nets, no tracks yet.

## Commit log (part)

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2026-06-16 fix: exclude VR1/VR2 from PCB update (on_board no)
2026-06-16 feat: add GF063P footprint for VR3-VR7
2026-06-16 feat: add GF063P footprint for VR3-VR7 (transceiver)
2026-06-16 feat: assign GF063P footprint to VR3-VR7
2026-06-16 feat: assign GF063P footprint to VR3-VR5
2026-06-16 fix: remove VR1/VR2 from netlist (on_board no)
2026-06-16 fix: exclude VR1/VR2 from footprint assignment, use GF063P for VR3-VR7
2026-06-16 fix: VR1/VR2 on_board=no, VR3-VR5 GF063P footprint in schematic generator
